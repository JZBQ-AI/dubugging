## boards/bioz/bioz_watch/board.yml
```yaml
board:
  name: bioz_watch
  full_name: BioZ Watch MDBT50Q-1MV2
  vendor: others
  socs:
    - name: nrf52840
```
